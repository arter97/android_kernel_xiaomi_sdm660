## drivers/input/fingerprint/Kconfig
```kconfig
config INPUT_FINGERPRINT
	tristate "Fingerprint driver support"

source "drivers/input/fingerprint/fpc/Kconfig"
```
